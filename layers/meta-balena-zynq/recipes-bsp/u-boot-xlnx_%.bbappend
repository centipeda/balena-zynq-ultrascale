inherit resin-u-boot


