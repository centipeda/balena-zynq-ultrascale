SUPERVISOR_REPOSITORY_mars-zx2 = "balena/armv7hf-supervisor"
SUPERVISOR_REPOSITORY_marspm3-zynq7 = "balena/armv7hf-supervisor"
LED_FILE_mars-zx2 = "/sys/class/leds/ds23/brightness"
SUPERVISOR_REPOSITORY_qemu-zynq7 = "balena/armv7hf-supervisor"