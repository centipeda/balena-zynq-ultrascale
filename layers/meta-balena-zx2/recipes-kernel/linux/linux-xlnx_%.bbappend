inherit kernel-resin
inherit kernel-balena
