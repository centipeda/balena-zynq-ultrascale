SUPERVISOR_REPOSITORY_mars-zx2 = "balena/armv7hf-supervisor"
LED_FILE_mars-zx2 = "/sys/class/leds/ds23/brightness"
