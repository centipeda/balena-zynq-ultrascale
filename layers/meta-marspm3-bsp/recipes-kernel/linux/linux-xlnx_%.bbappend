SRC_URI += "file://user_2019-10-04-11-26-00.cfg \
            file://user_2019-10-07-13-05-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

